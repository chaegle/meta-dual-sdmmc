FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-ccmp133-u-boot-enable-sdmmc1-emmc-and-sdmmc2-microSD.patch"

