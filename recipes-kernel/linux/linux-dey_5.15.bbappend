FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-ccmp13-kernel-Enable-8-bit-eMMC-sdmmc1-and-microSD-s.patch"

